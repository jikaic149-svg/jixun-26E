# Keil uVision project empty_LP_MSPM0G3519_nortos_keil.uvprojx, settings and files
target empty_LP_MSPM0G3519_nortos_keil (6220000::V6.22::ARMCLANG)
  device: MSPM0G3519 Texas Instruments
  pack: TexasInstruments.MSPM0GX51X_DFP.1.0.0
  cpu: IRAM(0x20000000,0x00010000) IRAM2(0x20100000,0x00010000) IROM(0x00000000,0x00080000) IROM2(0x00400000,0x00080000) XRAM(0x20200000,0x00020000) XRAM2(0x20300000,0x00010000) CPUTYPE("Cortex-M0+") CLOCK(12000000) ELITTLE
  output: empty_LP_MSPM0G3519_nortos_keil +hex
  BeforeMake: cmd.exe /C "$P../../../../../../tools/keil/syscfg.bat '$P' empty.syscfg"
  c flags: Optim=1 OneElfS=1 uC99=1 v6Lang=3 v6LangP=3 wLevel=4
  c define: __MSPM0G3519__
  c include: ../../../../../../source/third_party/CMSIS/Core/Include;../../../../../../source;..;../FreeRTOS/include
  asm include: ../FreeRTOS/include
  library: MicroLIB
  memory RVCT4: ROM 0x0 size 0x80000
  memory RVCT5: ROM 0x400000 size 0x80000
  memory RVCT6: RAM 0x20200000 size 0x20000
  memory RVCT7: RAM 0x20300000 size 0x10000
  memory RVCT9: RAM 0x20000000 size 0x10000
  memory RVCT10: RAM 0x20100000 size 0x10000
  scatter file: ./mspm0g3519.sct
  link misc: ../../../../../../source/ti/driverlib/lib/keil/m0p/mspm0gx51x/driverlib.a
  group Source
    ../: empty.c empty.syscfg ti_msp_dl_config.h ti_msp_dl_config.c
    ./: startup_mspm0g351x_uvision.s
  group APP
    ../APP/: app_main.c app_init.c app_ui.c app_motor.c app_comm.c
    ../APP/algorithm/: pid_controller.c
    ../APP/broker/: broker.c
    ../APP/framework/: daemon.c message_center.c simple_task_scheduler.c
  group BSP
    ../BSP/: bsp_init.c bsp_buzzer.c bsp_led.c bsp_key.c bsp_uart.c bsp_pwm.c bsp_qei.c bsp_ws2812.c bsp_motor.c
  group Device
    ../Device/: device_init.c motor.c device_buzzer.c device_led.c device_key.c device_ws2812.c motor_encoder.c bluetooth.c jy61p.c
    ../APP/algorithm/: crc16.c
  group System
    ../System/: isr.c
  group Mode
    ../Mode/: mode_manager.c MODE_IDLE.c MODE_STRAIGHT.c MODE_TURNING.c MODE_CURVE.c MODE_BRAKE.c MODE_DONE.c MODE_AXIS.c
  group Task
    ../Task/: MODE_TASK_TEST.c
  group FreeRTOS
    ../FreeRTOS/src/: tasks.c list.c queue.c timers.c event_groups.c
    ../FreeRTOS/portable/: port.c heap_4.c
